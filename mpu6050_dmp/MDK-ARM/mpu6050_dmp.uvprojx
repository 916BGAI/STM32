# Keil uVision project mpu6050_dmp.uvprojx, settings and files
target mpu6050_dmp (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: mpu6050_dmp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,EMPL,MPL_LOG_NDEBUG=0,MPU6050,USE_DMP,REMOVE_LOGGING,EMPL_TARGET_STM32F1
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/RTT;../Drivers/MPU6050_Motion_Driver/driver/eMPL;../Drivers/MPU6050_Motion_Driver/driver/include;../Drivers/MPU6050_Motion_Driver/eMPL-hal;../Drivers/MPU6050_Motion_Driver/mllite;../Drivers/MPU6050_Motion_Driver/mpl;../Drivers/MPU6050_Motion_Driver/porting
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/RTT
    ../Drivers/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c
  group Drivers/MPU6050_Motion_Driver/driver/eMPL
    ../Drivers/MPU6050_Motion_Driver/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Drivers/MPU6050_Motion_Driver/eMPL-hal
    ../Drivers/MPU6050_Motion_Driver/eMPL-hal/: eMPL_outputs.c
  group Drivers/MPU6050_Motion_Driver/mllite
    ../Drivers/MPU6050_Motion_Driver/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group Drivers/MPU6050_Motion_Driver/mpl
    ../Drivers/MPU6050_Motion_Driver/mpl/: libmpllib.lib
  group Drivers/MPU6050_Motion_Driver/porting
    ../Drivers/MPU6050_Motion_Driver/porting/: MPU6050.c STM32F1_porting.c
software components: CMSIS:CORE 5.6.0
