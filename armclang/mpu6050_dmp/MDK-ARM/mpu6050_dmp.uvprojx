# Keil uVision project mpu6050_dmp.uvprojx, settings and files
target mpu6050_dmp (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: mpu6050_dmp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,EMPL_TARGET_STM32F1,EMPL,MPL_LOG_NDEBUG = 0,MPU6050,USE_DMP,REMOVE_LOGGING
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/MPU6050_Motion_Driver/driver/eMPL;../Drivers/MPU6050_Motion_Driver/driver/include;../Drivers/MPU6050_Motion_Driver/driver/stm32L;../Drivers/MPU6050_Motion_Driver/eMPL-hal;../Drivers/MPU6050_Motion_Driver/mllite;../Drivers/MPU6050_Motion_Driver/mpl;../Drivers/MPU6050_Motion_Driver/porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/MPU6050_Motion_Driver/driver/eMPL
    ../Drivers/MPU6050_Motion_Driver/driver/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group Drivers/MPU6050_Motion_Driver/driver/include
    ../Drivers/MPU6050_Motion_Driver/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
  group Drivers/MPU6050_Motion_Driver/driver/stm32L
    ../Drivers/MPU6050_Motion_Driver/driver/stm32L/: log_stm32.c packet.h
  group Drivers/MPU6050_Motion_Driver/eMPL-hal
    ../Drivers/MPU6050_Motion_Driver/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
  group Drivers/MPU6050_Motion_Driver/mllite
    ../Drivers/MPU6050_Motion_Driver/mllite/: data_builder.c data_builder.h hal_outputs.c hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
  group Drivers/MPU6050_Motion_Driver/mpl
    ../Drivers/MPU6050_Motion_Driver/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h libmpllib.lib
  group Drivers/MPU6050_Motion_Driver/porting
    ../Drivers/MPU6050_Motion_Driver/porting/: STM32F1_porting.c STM32F1_porting.h MPU6050.c MPU6050.h
software components: CMSIS:CORE 5.6.0
